options:
  parameters:
    author: Matt Hostetter
    category: Custom
    generate_options: qt_gui
    id: app
    output_language: python
    title: ADS-B Receiver
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: int(1090e6)
  states: {}
- name: fs
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: gain
  id: variable
  parameters:
    value: '100'
  states: {}
- name: select_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '0.010'
  states: {state: disabled}
- name: threshold
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: fs
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/owen/marp/demo_data/adsb2
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/owen/marp/demo_data/adsb
    repeat: 'True'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: select_index
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 2*10**6
    type: float
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: fc
    gain1: '''hybrid'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: fs
    uri: ip:192.168.178.2
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    fbw: '0.4'
    interp: '12'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '5010'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '10'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5002
    timeout: '10'
    type: float
  states: {state: disabled}
- name: zeromq_pub_sink_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5004
    timeout: '10'
    type: complex
  states: {state: disabled}

connections:
- [adsb_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [adsb_demod_0, '0', blocks_null_sink_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [adsb_framer_1, '0', blocks_file_sink_1, '0']
- [analog_wfm_rcv_0, '0', zeromq_pub_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', adsb_framer_1, '0']
- [iio_fmcomms2_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_selector_0, '0']
- [iio_fmcomms2_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
